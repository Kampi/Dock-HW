File: dock/Block Diagram.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Prepare release
- Set variant to CHECKED
- Remove unused files
- Fix ERC errors
- Fix DRC errors
- Remove Power Sequencing page
- Add block diagram

Signed-off-by: Daniel Kampert <DanielKampert@kampis-elektroecke.de>

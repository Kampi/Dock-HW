# Repository Kampi/Dock-HW

File README.md:

# ZSWatch-Dock

## 📑 Table of Contents

- [ZSWatch-Dock](#zswatch-dock)
  - [📑 Table of Contents](#-table-of-contents)
  - [📖 About](#-about)
  - [📂 Directory Breakdown](#-directory-breakdown)
  - [Purchasing](#purchasing)
  - [Ressources](#ressources)
  - [👨‍💻 Maintainer](#-maintainer)

## 📖 About

The **ZSWatch-Dock** project provides the hardware design and production files for a docking station tailored to the ZSWatch ecosystem.  
It is built with **KiCad** and integrates a full **CI/CD pipeline** using **KiBot**, ensuring reproducible outputs for documentation, manufacturing, and releases.

Key features:

- 🛠️ Open-source hardware design
- 📦 Automated generation of Gerber, BoM, and documentation via KiBot
- 🔄 Workflow stages (DRAFT → PRELIMINARY → CHECKED → RELEASED) for structured releases
- 📝 Clear documentation and changelog to track progress
- 🌍 Designed with collaboration and transparency in mind

Please check the [wiki](https://github.com/ZSWatch/ZSWatch/wiki) for more information about the project.

## 📂 Directory Breakdown

- **`.github`**: GitHub related files
- **`.gitignore`**: Ignored files list
- **`dock`**: KiCad project for the dock
- **`production`**: Manufacturing outputs (Gerbers, documentation, etc.)
- **`CHANGELOG.md`**: Version history
- **`LICENSE`**: Project license (GPL-3.0)
- **`README.md`**: Project overview

## Purchasing

TBD

## Ressources

- [KiBot Template](https://github.com/nguyen-v/KDT_Hierarchical_KiBot)

## 👨‍💻 Maintainer

- [Daniel Kampert](mailto:danielkameprt@kampis-elektroecke.de)
- [Jakob Krantz](mailto:mail@jakobkrantz.se)

## KiCad design dock/ZSWatch-Dock.kicad_pcb

Board: 4 copper layers, 80.0 x 48.0 mm, 70 parts (3 on the bottom side), 51 nets.

Parts:
C401, C403, C404, C405, C406, C407, C409, C414, C415, C416, C417, C418, C419: 100n; C_0603_1608Metric
C402, C411: 2u2; C_0603_1608Metric
C408: 470p; C_0603_1608Metric
C410: 1u; C_0603_1608Metric
C412, C413: 18p; C_0603_1608Metric
D401, D402: ESD5Zxx; D_SOD-523
D403: USB; LED_0603_1608Metric
D404: Charge; LED_0603_1608Metric
IC401: TLV70218_SOT23-5; SOT-23-5
IC402, IC406, IC408: USBLC6-2P6; SOT-666
IC403: FT230XQ; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm
IC404: MIC5219-3.3YM5; SOT-23-5
IC405: TXB0304RUT; Texas_R-PUQFN-N12
IC407: USB2512BT; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm
IC409: MIC2026-1xM; SOIC-8_3.9x4.9mm_P1.27mm
J402: Voltage; PinHeader_1x03_P2.54mm_Vertical
Q401: BSH205G2AR; SOT-23
R401, R404, R408, R412, R413, R414, R419, R420: 100k; R_0603_1608Metric
R402, R403: 22R; R_0603_1608Metric
R405, R406, R418: 0R; R_0805_2012Metric
R407: 3k3; R_0603_1608Metric
R409, R410, R415, R416: 5k1; R_0603_1608Metric
R411: 1M; R_0603_1608Metric
R417: 12k / 1%; R_0603_1608Metric
R421: 620R; R_0603_1608Metric
S401: Reset; WS-TASV-6x6
SB401: Resetn; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
SB402: SWDCLK; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
SB403: SWDIO; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
SW401: Charge; SW_SPDT_PCM12
X401: Debug; SHF-105-01-L-D-SM-TR
X402: UART; PinHeader_1x03_P2.54mm_Vertical
X403: Host; USB_C_Receptacle_Amphenol_12401610E4-2A
X404: Device; 10133475-10001LF
X405: Current; PinHeader_1x02_P2.54mm_Horizontal
Y401: 24 MHz; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm
kibuzzard-6832BFA7: G***; kibuzzard-6832BFA7
kibuzzard-6832BFEF: G***; kibuzzard-6832BFEF
kibuzzard-68303879: G***; kibuzzard-68303879
kibuzzard-68304463: G***; kibuzzard-68304463

Connections:
+1V8: C402.1, C407.1, C409.1, IC401.5 (OUT), IC403.1 (VCCIO), IC405.1 (VCCA), J402.3, R405.1
+3V3: C404.1, C405.1, C410.1, C411.1, C415.1, C416.1, IC403.8 (3V3OUT), IC403.10 (VCC), IC404.5 (OUT), IC407.5 (VDDA), IC407.10 (VDDA), IC407.15 (VDD), IC407.23 (VDD), IC407.29 (VDDA), IC407.36 (VDDA), J402.1, R401.1, R404.1, R412.1, R413.1, R414.1
/Project Architecture/Main/D+: IC406.4 (I/O2), X403.A6 (D+), X403.B6 (D+)
/Project Architecture/Main/D-: IC406.6 (I/O1), X403.A7 (D-), X403.B7 (D-)
/Project Architecture/Main/D_{2}+: IC408.4 (I/O2), X404.A6 (D+), X404.B6 (D+)
/Project Architecture/Main/D_{2}-: IC408.6 (I/O1), X404.A7 (D-), X404.B7 (D-)
EN_{OC1}: IC407.12 (PRTPWR1/BC_EN1), IC409.1 (ENA), R412.2
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.1, C413.1, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, D402.2 (A), D403.1 (K), IC401.2 (GND), IC402.2 (GND), IC403.3 (GND), IC403.13 (GND), IC403.17 (GND), IC404.2 (GND), IC405.6 (GND), IC406.2 (GND), IC407.16 (PRTPWR2/BC_EN2), IC407.24 (SCL/SMBCLK/CFG_SEL0), IC407.25 (HS_IND/CFG_SEL1), IC407.37 (GND), IC408.2 (GND), IC409.6 (GND), R406.2, R408.2, R409.2, R410.1, R415.2, R416.1, R417.2, R419.2, S401.2, SW401.2 (B), X401.3 (GND), X401.5 (GND), X402.2, X403.A1 (GND), X403.A12 (GND), X403.B1 (GND), X403.B12 (GND), X403.S1 (SHIELD), X404.A1 (GND), X404.A12 (GND), X404.B1 (GND), X404.B12 (GND), X404.S1 (SHIELD), Y401.2, Y401.4
unnamed: C406.1, D401.1 (K), IC402.5 (VBUS), IC405.11 (VCCB), J402.2, X401.1 (VTref)
unnamed: D403.2 (A), R407.1
unnamed: D404.2 (A), R421.1
unnamed: D404.1 (K), Q401.1 (G), R420.1, SW401.3 (C)
unnamed: IC402.6 (I/O1), R402.1
unnamed: IC402.4 (I/O2), R403.1
unnamed: C403.1, IC403.9 (~RESET), R404.2
unnamed: C408.1, IC404.4 (BP)
unnamed: IC402.1 (I/O1), IC405.8 (B3), SB402.1 (A)
unnamed: IC402.3 (I/O2), IC405.7 (B4), SB403.1 (A)
unnamed: IC405.12 (OE), R405.2, R406.1
unnamed: C418.1, IC407.14 (CRFILT)
unnamed: IC407.13 (OCS_{N1}), IC409.2 (FLGA)
unnamed: C417.1, IC407.34 (PLLFILT)
unnamed: IC407.35 (RBIAS), R417.1
unnamed: IC407.22 (SDA/SMBDATA/NON_REM1), R413.2
unnamed: IC407.28 (SUSP_IND/LOCAL_PWR/NON_REM0), R407.2, R408.1
unnamed: C412.2, IC407.33 (XTAL_{IN}), R411.1, Y401.1
unnamed: C413.2, IC407.32 (XTAL_{OUT}), R411.2, Y401.3
unnamed: C414.1, IC407.26 (~RESET), R414.2
unnamed: IC409.4 (ENB), R419.1
unnamed: Q401.3 (D), R418.1, X405.2
unnamed: R402.2, X401.4 (SWCLK/TCK)
unnamed: R403.2, X401.2 (SWDIO/TMS)
unnamed: R410.2, X403.A5 (CC1)
unnamed: R409.1, X403.B5 (CC2)
unnamed: R416.2, X404.A5 (CC1)
unnamed: R415.1, X404.B5 (CC2)
unnamed: R418.2, X404.A4 (VBUS), X404.A9 (VBUS), X404.B4 (VBUS), X404.B9 (VBUS), X405.1
RESETn: C401.1, D401.2 (A), D402.1 (K), IC405.9 (B2), IC405.10 (B1), R401.2, S401.1, SB401.1 (A), X401.10 (~RESET)
RESETn_{LV}: IC405.2 (A1), IC405.3 (A2), SB401.2 (B), X404.A8 (SBU1), X404.B8 (SBU2)
RxD_{LV}: IC403.2 (RXD), X402.1, X404.A11 (RX2+), X404.B11 (RX1+)
SWDCLK_{LV}: IC405.4 (A3), SB402.2 (B), X404.A2 (TX1+), X404.B2 (TX2+)
SWDIO_{LV}: IC405.5 (A4), SB403.2 (B), X404.A3 (TX1-), X404.B3 (TX2-)
TxD_{LV}: IC403.15 (TXD), X402.3, X404.A10 (RX2-), X404.B10 (RX1-)
USB-1-D+: IC403.6 (USBDP), IC407.4 (USBDP_{N2})
USB-1-D-: IC403.7 (USBDM), IC407.3 (USBDM_{N2})
USB-2-D+: IC407.2 (USBDP_{N1}), IC408.3 (I/O2)
USB-2-D-: IC407.1 (USBDM_{N1}), IC408.1 (I/O1)
USB-D+: IC406.3 (I/O2), IC407.31 (USBDP_{UP})
USB-D-: IC406.1 (I/O1), IC407.30 (USBDM_{UP})
V_{BUS}: C419.1, IC401.1 (IN), IC401.3 (EN), IC404.1 (IN), IC404.3 (EN), IC406.5 (VBUS), IC407.27 (VBUS), IC409.7 (IN), X403.A4 (VBUS), X403.A9 (VBUS), X403.B4 (VBUS), X403.B9 (VBUS)
V_{Watch}: IC408.5 (VBUS), IC409.8 (OUTA), Q401.2 (S), R420.2, R421.2

## Commit log

2025-09-07 Prepare release
    - Set variant to CHECKED
    - Remove unused files
    - Fix ERC errors
    - Fix DRC errors
    - Remove Power Sequencing page
    - Add block diagram
2025-09-07 Update CHANGELOG
2025-09-07 Update outputs (release)
2025-09-07 Add 'Resources' section to README
    Added a new section for resources with a link to the KiBot template.
2025-09-07 Push outputs from CI/CD (2025-09-07 19:59:27)
2025-09-18 Release 2.2.0
    - Set variant to CHECKED
    - Remove unused files
    - Fix ERC errors
    - Fix DRC errors
    - Remove Power Sequencing page
    - Add block diagram
2026-06-01 Push outputs from CI/CD (2026-06-01 11:18:39)
2026-06-01 Push outputs from CI/CD (2026-06-01 11:51:48)
